options:
  parameters:
    author: cemal
    generate_options: qt_gui
    id: raw_file_8psk
    output_language: python
    title: Raw File 8PSK
  states: {}

blocks:
- name: bw_slider
  id: variable_qtgui_range
  parameters:
    comment: 0,9,1,1
    gui_hint: 2,9,1,1
    label: Bandwidth
    rangeType: int
    start: '200000'
    step: '10000000'
    stop: '52000000'
    value: '5000000'
  states: {}
- name: constellation
  id: variable_constellation
  parameters:
    const_points: '[0.924+0.383j,0.383+0.924j,-0.924+0.383j,-0.383+0.924j,-0.383-0.924j,-0.924-0.383j,0.924-0.383j,0.383-0.924j]'
    dims: '1'
    normalization: digital.constellation.NO_NORMALIZATION
    npwr: '0'
    precision: '8'
    rot_sym: '8'
    sym_map: '[0,4,5,1,3,7,6,2]'
    type: calcdist
  states: {}
- name: delay
  id: variable_qtgui_range
  parameters:
    comment: 1,9,1,1
    gui_hint: 1,9,1,1
    label: Delay
    rangeType: int
    start: '0'
    step: '1'
    stop: '100000'
    value: '52'
  states: {}
- name: freq
  id: variable
  parameters:
    value: '745000000'
  states: {}
- name: freq_slider
  id: variable_qtgui_range
  parameters:
    comment: 0,9,1,1
    gui_hint: 0,9,1,1
    label: Frequency
    rangeType: int
    start: '500000000'
    step: '1000000'
    stop: '3200000000'
    value: '2400000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: samp_rate_slider
  id: variable_qtgui_range
  parameters:
    comment: 0,9,1,1
    gui_hint: 4,9,1,1
    label: Sample Rate
    rangeType: int
    start: '100000'
    step: '100000'
    stop: '10000000'
    value: '4000000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '10'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: ./bitstream_tx.txt
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: ./received_83_8psk_10sps_1Msr_5Mbw.bin
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: ./transmitted_83.bin
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '3'
  states: {}
- name: blocks_unpack_k_bits_bb_0_1
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constellation
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: constellation
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: sps
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '8'
    w: '0.0628'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '8'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    comment: Gray coding
    map: '[0,4,5,1,3,7,6,2]'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: filter_fft_rrc_filter_0
  id: filter_fft_rrc_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: ccc
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '0'
    bandwidth: bw_slider
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: freq
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.2.1
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: bw_slider
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: freq
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.3.1
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    comment: 0,0,1,8
    grid: 'True'
    gui_hint: 0,0,1,8
    label1: Before Costas Loop
    label2: After Costas Loop
    nconnections: '2'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_eye_sink_x_0
  id: qtgui_eye_sink_x
  parameters:
    autoscale: 'True'
    samp_per_symbol: sps
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: TX
  states: {state: disabled}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: RX
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: RX
  states: {}
- name: virtual_source_2_0
  id: virtual_source
  parameters:
    stream_id: TX
  states: {state: disabled}

connections:
- [blocks_file_source_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_pack_k_bits_bb_0, '0', digital_constellation_modulator_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [blocks_unpack_k_bits_bb_0, '0', blocks_file_sink_0_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_probe_rate_0, '0']
- [blocks_unpack_k_bits_bb_0_1, '0', blocks_file_sink_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_modulator_0, '0', iio_pluto_sink_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '1']
- [digital_costas_loop_cc_0, '0', qtgui_eye_sink_x_0, '0']
- [digital_diff_decoder_bb_0, '0', virtual_sink_0_0_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_0, '0']
- [filter_fft_rrc_filter_0, '0', digital_symbol_sync_xx_0, '0']
- [iio_pluto_source_0, '0', filter_fft_rrc_filter_0, '0']
- [virtual_source_1, '0', digital_map_bb_0, '0']
- [virtual_source_2_0, '0', blocks_unpack_k_bits_bb_0_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
