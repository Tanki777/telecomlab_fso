options:
  parameters:
    author: cemal
    generate_options: qt_gui
    id: pluto_bpsk_rx
    output_language: python
    title: Pluto BPSK Rx
  states: {}

blocks:
- name: access_key
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: constellation
  id: variable_constellation
  parameters:
    const_points: '[-1-0j, 1+0j]'
    dims: '1'
    normalization: digital.constellation.NO_NORMALIZATION
    npwr: '0'
    precision: '8'
    rot_sym: '2'
    sym_map: '[0, 1]'
    type: calcdist
  states: {}
- name: freq
  id: variable
  parameters:
    value: '745000000'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: byte
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constellation
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: '0.0628'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: file_sink_unpackaged_bpsk_0
  id: file_sink_unpackaged_bpsk
  parameters:
    file_name: '"./bpsk.tmp"'
  states: {}
- name: filter_fft_rrc_filter_0
  id: filter_fft_rrc_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: ccc
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: freq
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.3.1
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    comment: 0,0,1,8
    grid: 'True'
    gui_hint: 0,0,1,8
    label1: Before Costas Loop
    label2: After Costas Loop
    nconnections: '2'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 2,0,1,4
    name: '"Uncorrelated"'
    size: '256'
    srate: samp_rate
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 2,5,1,4
    name: '"Correlated"'
    size: '256'
    srate: samp_rate
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: '3'
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: '3'
  states: {}

connections:
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0_0, '1']
- [digital_diff_decoder_bb_0, '0', virtual_sink_0_0_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_0_0, '0']
- [file_sink_unpackaged_bpsk_0, '0', qtgui_time_sink_x_1, '0']
- [file_sink_unpackaged_bpsk_0, '1', qtgui_time_sink_x_1_0, '0']
- [filter_fft_rrc_filter_0, '0', digital_symbol_sync_xx_0, '0']
- [iio_pluto_source_0, '0', filter_fft_rrc_filter_0, '0']
- [virtual_source_2, '0', blocks_probe_rate_0, '0']
- [virtual_source_2, '0', file_sink_unpackaged_bpsk_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
