options:
  parameters:
    author: cemal
    generate_options: qt_gui
    id: pluto_8psk_tx
    output_language: python
    title: Pluto 8PSK Tx
  states: {}

blocks:
- name: access_key
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: constellation
  id: variable_constellation
  parameters:
    const_points: '[0.924+0.383j,0.383+0.924j,-0.924+0.383j,-0.383+0.924j,-0.383-0.924j,-0.924-0.383j,0.924-0.383j,0.383-0.924j]'
    dims: '1'
    normalization: digital.constellation.NO_NORMALIZATION
    npwr: '0'
    precision: '8'
    rot_sym: '8'
    sym_map: '[0,4,5,1,3,7,6,2]'
    type: calcdist
  states: {}
- name: freq
  id: variable
  parameters:
    value: '745000000'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: samp_per_sym
  id: variable
  parameters:
    value: '2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: constellation
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: samp_per_sym
  states: {}
- name: file_source_packaged_0
  id: file_source_packaged
  parameters:
    file_name: '"./test_file_tx.txt"'
    packet_length: '52'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '40'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: freq
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.2.1
  states: {}

connections:
- [digital_constellation_modulator_0, '0', iio_pluto_sink_0, '0']
- [file_source_packaged_0, '0', digital_constellation_modulator_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
