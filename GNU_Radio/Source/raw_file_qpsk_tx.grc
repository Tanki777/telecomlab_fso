options:
  parameters:
    author: cemal
    generate_options: qt_gui
    id: raw_file_qpsk_tx
    output_language: python
    title: Raw File QPSK Tx
  states: {}

blocks:
- name: bw_slider
  id: variable_qtgui_range
  parameters:
    comment: 0,9,1,1
    gui_hint: 2,9,1,1
    label: Bandwidth
    rangeType: int
    start: '200000'
    step: '10000000'
    stop: '52000000'
    value: '5000000'
  states: {}
- name: constellation
  id: variable_constellation
  parameters:
    const_points: '[-0.707-0.707j, -0.707+0.707j, 0.707+0.707j, 0.707-0.707j]'
    dims: '1'
    normalization: digital.constellation.NO_NORMALIZATION
    npwr: '0'
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    type: calcdist
  states: {}
- name: freq
  id: variable
  parameters:
    value: freq_slider
  states: {}
- name: freq_slider
  id: variable_qtgui_range
  parameters:
    comment: 0,9,1,1
    gui_hint: 0,9,1,1
    label: Frequency
    rangeType: int
    start: '500000000'
    step: '1000000'
    stop: '4200000000'
    value: '745000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: samp_rate_slider
  id: variable_qtgui_range
  parameters:
    comment: 0,9,1,1
    gui_hint: 4,9,1,1
    label: Sample Rate
    rangeType: int
    start: '100000'
    step: '100000'
    stop: '10000000'
    value: '2000000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: ./transmitted_new2.bin
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: constellation
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: sps
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '0'
    bandwidth: bw_slider
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: freq
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.2.1
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_pack_k_bits_bb_0, '0', digital_constellation_modulator_0, '0']
- [digital_constellation_modulator_0, '0', iio_pluto_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
