options:
  parameters:
    generate_options: hb
    id: file_source_packaged
    output_language: python
    title: File Source Packaged
  states: {}

blocks:
- name: access_key
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: hdr_format
  id: variable
  parameters:
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr_format
    len_tag_key: '"packet_len"'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    FileName: file_name
    Pkt_len: packet_length
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt
      import os
      import base64
      import time

      """
      State definitions
          0   idle
          1   send preamble
          2   send file data
          3   send file name
          4   send post filler
      """

      class blk(gr.basic_block):
          def __init__(self, FileName='None', Pkt_len=52):
              gr.basic_block.__init__(
                  self,
                  name='EPB: File Source to Tagged Stream',
                  in_sig=None,
                  out_sig=[np.uint8]
              )

              self.FileName = FileName
              self.Pkt_len = Pkt_len
              self.state = 0
              self.pre_count = 0
              self._eof = False
              self.pkt_num = 1

              self.tx_buf = bytearray()

              if os.path.exists(self.FileName):
                  self.f_in = open(self.FileName, 'rb')
                  self.state = 1
              else:
                  print(self.FileName, 'does not exist')
                  self._eof = True

              # Preamble
              self.char_list = [
                  37,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,
                  85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,
                  85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,
                  85,85,85,93
              ]
              self.c_len = len(self.char_list)

              # Filler
              self.filler = [
                  37,85,85,85,35,69,79,70,
                  85,85,85,85,85,85,85,85,
                  85,85,85,85,85,85,85,85,
                  85,85,85,85,85,85,85,85,
                  85,85,85,85,85,85,85,85,
                  85,85,85,85,85,85,85,85,
                  85,85,85,93
              ]
              self.f_len = len(self.filler)
              self.t_start = time.time()

          def _add_packet(self, payload):
              """Append payload to tx buffer and tag it."""
              tag_offset = self.nitems_written(0) + len(self.tx_buf)
              self.add_item_tag(
                  0,
                  tag_offset,
                  pmt.intern("packet_len"),
                  pmt.from_long(len(payload))
              )
              self.tx_buf.extend(payload)

          def general_work(self, input_items, output_items):

              # Fill TX buffer if empty
              while len(self.tx_buf) == 0 and self.state != 0:

                  if self.state == 1:
                      # Send preamble
                      self._add_packet(bytes(self.char_list))
                      self.pre_count += 1
                      if self.pre_count > 64:
                          self.pre_count = 0
                          self.state = 2
                      break

                  elif self.state == 2:
                      buff = self.f_in.read(self.Pkt_len)
                      if len(buff) == 0:
                          print("End of File")
                          print("Time: ", time.time()-self.t_start)
                          print("Total payload packets: ", self.pkt_num-1) # lower pkt number by 1
                          self.f_in.close()
                          self.state = 3
                          break

                      pkt_num_padded = str(self.pkt_num).zfill(6)
                      pkt_num_frame = f"[{pkt_num_padded}]"
                      pkt_num_frame_encoded = pkt_num_frame.encode('utf-8')

                      encoded = pkt_num_frame_encoded + base64.b64encode(buff)
                      self._add_packet(encoded)

                      self.pkt_num += 1
                      break

                  elif self.state == 3:
                      name_bytes = self.FileName.encode('ascii')
                      payload = bytes(self.filler[:8]) + name_bytes
                      self._add_packet(payload)
                      self.state = 4
                      break

                  elif self.state == 4:
                      self._add_packet(bytes(self.filler))
                      self.pre_count += 1
                      if self.pre_count > 64:
                          self.pre_count = 0
                          self.state = 0
                      break

              # Output only what fits
              n = min(len(self.tx_buf), len(output_items[0]))
              output_items[0][:n] = self.tx_buf[:n]
              del self.tx_buf[:n]

              self.consume(0, 0)

              return n
  states: {}
- name: file_name
  id: parameter
  parameters:
    label: File Name
    type: str
    value: '"./in.txt"'
  states: {}
- name: packet_length
  id: parameter
  parameters:
    label: Packet Length
    type: intx
    value: '60'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: byte
  states: {}

connections:
- [blocks_tagged_stream_mux_0, '0', pad_sink_0, '0']
- [digital_crc32_bb_0, '0', blocks_tagged_stream_mux_0, '1']
- [digital_crc32_bb_0, '0', digital_protocol_formatter_bb_0, '0']
- [digital_protocol_formatter_bb_0, '0', blocks_tagged_stream_mux_0, '0']
- [epy_block_0, '0', digital_crc32_bb_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
